SRCBRANCH = "imx_4.14.98_2.3.0"

SRCREV = "09c5cc994634060ad7dfef4620866838d19694a4"
